** Library name: ECE555
** Cell name: AND_2
** View name: schematic
mn2 y net2 vss! vss! nmos_lvt w=27e-9 l=20e-9 nfin=1
mn1 net2 b net1 net1 nmos_lvt w=27e-9 l=20e-9 nfin=1
mn0 net1 a vss! vss! nmos_lvt w=27e-9 l=20e-9 nfin=1
mp5 y net2 vdd! vdd! pmos_lvt w=27e-9 l=20e-9 nfin=1
mp4 net2 b vdd! vdd! pmos_lvt w=27e-9 l=20e-9 nfin=1
mp3 net2 a vdd! vdd! pmos_lvt w=27e-9 l=20e-9 nfin=1
